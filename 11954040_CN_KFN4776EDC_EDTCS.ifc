Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [COBie2.4DesignDeliverable]
File name: 0001
Time: 2024-03-18T12:07:50
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 21.1.21.45 - Exporter 21.1.21.45 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Mon Mar 18 12:07:50 2024 * Host: DEGTL11901 * Database: C:\Users\deschvi\AppData\Local\Temp\2424abfd-4859-4e72-9304-bfa5b83a34b1\200899c4-246c-4964-b340-a995bb7eb801\ifc * Database version: 5507 * Database creation date: Mon Mar 18 12:07:50 2024 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Mon Mar 18 12:07:50 2024 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Mon Mar 18 12:07:50 2024 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Pset_ProductRequirements - Category: Project Information

# IfcBuildingElementProxy: 11954040_CN_KFN4776EDC_EDTCS:38477650_CN_11954040_KFN4776EDC_EDTCS, (2)
In: Default
Type - Material: z_Miele_Design_Glass Black
Type - Pset_BuildingElementProxyCommon - Reference: 38477650_CN_11954040_KFN4776EDC_EDTCS
Type - Pset_QuantityTakeOff - Reference: 38477650_CN_11954040_KFN4776EDC_EDTCS
Material: z_Miele_Design_Glass Black, z_Miele_Design_OBSW, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Connection_Modul, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - sets with these values: 2
Pset_ProductRequirements - Category: Specialty Equipment
